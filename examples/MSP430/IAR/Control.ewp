# IAR project Control.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR2355 MSP430FR2355
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CONTROL_EXAMPLE
  ICC430.IExtraOptions: -f"..\ControlCpp-mbeeConfig.dat"
  ICC430.newCCIncludePaths: ../../../../cpp-mbee/includes; ../driverlib/MSP430FR2xx_4xx
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2355.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG; CONTROL_EXAMPLE
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: Board.h macros.h
  group Application
    ../: Control.cpp Control.h
  group Console
    ../: console.cpp console.h uart.c uart.h
  group cpp-mbee
    ../: cpp-mbeeConfig.dat
    ../../../: MBee.cpp MSP430Serial.cpp SerialStar.cpp System.cpp
  group driverlib
    ../driverlib/MSP430FR2xx_4xx/: cs.c eusci_a_uart.c gpio.c pmm.c timer_b.c wdt_a.c
