# IAR project Alarm.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.IExtraOptions: -f"..\AlarmCpp-mbeeConfig.dat"
  ICC430.newCCIncludePaths: ../; ../../../../../../../../../includes; ../../../Tools
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  group (top)
    ../../../Tools/: BOOSTXL-MBEE868-1.1.h macros.h
  group Application
    ../: Alarm.cpp Alarm.h
  group Config
    ../: AlarmCpp-mbeeConfig.dat
  group cpp-mbee
    ../../../../../../../../../: MBee.cpp MSP430Serial.cpp SerialStar.cpp System.cpp
