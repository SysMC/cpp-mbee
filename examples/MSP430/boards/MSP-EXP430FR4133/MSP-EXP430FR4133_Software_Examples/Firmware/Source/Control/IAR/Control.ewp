# IAR project Control.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.IExtraOptions: -f"..\ControlCpp-mbeeConfig.dat"
  ICC430.newCCIncludePaths: ../; ../../../../../../../../../includes; ../../../Tools; ../../../Tools/driverlib/MSP430FR2xx_4xx
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2355.xcl
  group (top)
    ../../../Tools/: Board.h BOOSTXL-MBEE868-1.1.h macros.h
  group Application
    ../: Control.cpp Control.h
  group Config
    ../: ControlCpp-mbeeConfig.dat
  group cpp-mbee
    ../../../../../../../../../: MBee.cpp MSP430Serial.cpp SerialStar.cpp System.cpp
  group driverlib
    ../../../Tools/driverlib/MSP430FR2xx_4xx/: adc.c cs.c gpio.c pmm.c timer_a.c wdt_a.c
